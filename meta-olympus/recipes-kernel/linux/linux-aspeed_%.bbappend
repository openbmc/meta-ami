FILESEXTRAPATHS_prepend_olympus := "${THISDIR}/${PN}:"
SRC_URI += "file://0001_arch_arm_boot_dts_olympus.patch"
