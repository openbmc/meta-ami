FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://0001-arch-arm-boot-dts-wolfpass.dts.patch"
SRC_URI += "file://0002-arch-arm-boot-dts-aspeed-g5.dtsi.patch"
